# Keil uVision project cyt2b95_led_blink_systick.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: CYT2B95CAE:Cortex-M4 Infineon
  pack: Infineon.CAT1A_DFP.1.6.0
  cpu: IRAM(0x08000000,0x40000) IROM(0x10000000,0x210000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cyt2b95_led_blink_systick.axf +hex
  c flags: Optim=6 OneElfS=1 wLevel=3
  c define: COMPONENT_ARM COMPONENT_CAT1 COMPONENT_CAT1A COMPONENT_CM0P_SLEEP COMPONENT_CM4 COMPONENT_CM4_0 COMPONENT_CYT2B95 COMPONENT_Debug COMPONENT_MW_CAT1CM0P COMPONENT_MW_CMSIS COMPONENT_MW_CORE_LIB COMPONENT_MW_CORE_MAKE COMPONENT_MW_MTB_HAL_CAT1 COMPONENT_MW_MTB_PDL_CAT1 COMPONENT_MW_RECIPE_MAKE_CAT1A COMPONENT_MW_RETARGET_IO COMPONENT_SOFTFP COMPONENT_TVIIBE2M CORE_NAME_CM4_0="1" CYT2B95CAE CY_APPNAME_mtb_t2g_example_systick_led CY_SUPPORTS_DEVICE_VALIDATION CY_TARGET_BOARD="CYT2B95" CY_USING_HAL DEBUG TARGET_CYT2B95
  c misc: -Wno-packed -Wno-missing-variable-declarations -Wno-missing-prototypes -Wno-missing-noreturn -Wno-nonportable-include-path -Wno-reserved-id-macro -Wno-unused-macros -Wno-documentation-unknown-command -Wno-documentation -Wno-license-management -Wno-parentheses-equality -Wno-packed -Wno-missing-variable-declarations -Wno-missing-prototypes -Wno-missing-noreturn -Wno-nonportable-include-path -Wno-reserved-id-macro -Wno-unused-macros -Wno-documentation-unknown-command -Wno-documentation -Wno-license-management -Wno-parentheses-equality
  c include: bsps/TARGET_CYT2B95;bsps;.;bsps/TARGET_CYT2B95/config/GeneratedSource;bsps/TARGET_CYT2B95/config;../mtb_shared/retarget-io/release-v1.8.0/include;../mtb_shared/retarget-io/release-v1.8.0;../mtb_shared/cat1cm0p/release-v1.9.0/COMPONENT_CAT1A;../mtb_shared/cat1cm0p/release-v1.9.0;../mtb_shared/cmsis/release-v5.8.2/Core/Include;../mtb_shared/cmsis/release-v5.8.2/Core;../mtb_shared/cmsis/release-v5.8.2;../mtb_shared/core-lib/release-v1.5.0/include;../mtb_shared/core-lib/release-v1.5.0;../mtb_shared/mtb-hal-cat1/release-v2.7.4/COMPONENT_CAT1A/include/pin_packages;../mtb_shared/mtb-hal-cat1/release-v2.7.4/COMPONENT_CAT1A/include;../mtb_shared/mtb-hal-cat1/release-v2.7.4/COMPONENT_CAT1A;../mtb_shared/mtb-hal-cat1/release-v2.7.4;../mtb_shared/mtb-hal-cat1/release-v2.7.4/COMPONENT_CAT1A/include/triggers;../mtb_shared/mtb-hal-cat1/release-v2.7.4/include;../mtb_shared/mtb-hal-cat1/release-v2.7.4/include_pvt;../mtb_shared/mtb-hal-cat1/release-v2.7.4/source;../mtb_shared/mtb-pdl-cat1/release-v3.17.0/devices/COMPONENT_CAT1A/include;../mtb_shared/mtb-pdl-cat1/release-v3.17.0/devices/COMPONENT_CAT1A;../mtb_shared/mtb-pdl-cat1/release-v3.17.0/devices;../mtb_shared/mtb-pdl-cat1/release-v3.17.0;../mtb_shared/mtb-pdl-cat1/release-v3.17.0/devices/COMPONENT_CAT1A/include/ip;../mtb_shared/mtb-pdl-cat1/release-v3.17.0/drivers/include;../mtb_shared/mtb-pdl-cat1/release-v3.17.0/drivers;../mtb_shared/mtb-pdl-cat1/release-v3.17.0/drivers/third_party/ethernet/include;../mtb_shared/mtb-pdl-cat1/release-v3.17.0/drivers/third_party/ethernet;../mtb_shared/mtb-pdl-cat1/release-v3.17.0/drivers/third_party
  asm include: as above
  memory RVCT4: ROM 0x10000000 size 0x210000
  memory RVCT9: RAM 0x8000000 size 0x40000
  scatter file: bsps/TARGET_CYT2B95/COMPONENT_CM4/TOOLCHAIN_ARM/linker.sct
  group sources
    ./bsps/TARGET_CYT2B95/COMPONENT_CM4/TOOLCHAIN_ARM/: startup_tviibe2m_cm4.s
    ./bsps/TARGET_CYT2B95/COMPONENT_CM4/: system_psoc6_cm4.c
    ./bsps/TARGET_CYT2B95/config/GeneratedSource/: cycfg.c cycfg_clocks.c cycfg_pins.c cycfg_system.c cycfg.h cycfg_clocks.h cycfg_notices.h cycfg_pins.h cycfg_routing.h cycfg_system.h
    ./bsps/TARGET_CYT2B95/: cybsp.c cybsp.h cybsp_doc.h cybsp_hw_config.h cybsp_types.h system_psoc6.h tviibe_partition.h
    ./: main.c
  group cat1cm0p
    ../mtb_shared/cat1cm0p/release-v1.9.0/COMPONENT_CAT1A/COMPONENT_CM0P_SLEEP/: psoc6_01_cm0p_sleep.c psoc6_02_cm0p_sleep.c psoc6_03_cm0p_sleep.c psoc6_04_cm0p_sleep.c tviibe1m_cm0p_sleep.c tviibe2m_cm0p_sleep.c tviibe4m_cm0p_sleep.c tviibe512k_cm0p_sleep.c xmc5100_cm0p_sleep.c xmc5200_cm0p_sleep.c xmc5300_cm0p_sleep.c
    ../mtb_shared/cat1cm0p/release-v1.9.0/COMPONENT_CAT1A/: mtb_cat1cm0p.h
  group cmsis
    ../mtb_shared/cmsis/release-v5.8.2/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
  group core-lib
    ../mtb_shared/core-lib/release-v1.5.0/include/: cy_result.h cy_utils.h
  group mtb-hal-cat1
    ../mtb_shared/mtb-hal-cat1/release-v2.7.4/COMPONENT_CAT1A/source/pin_packages/: cyhal_psoc6_01_104_m_csp_ble.c cyhal_psoc6_01_104_m_csp_ble_usb.c cyhal_psoc6_01_116_bga_ble.c cyhal_psoc6_01_116_bga_usb.c cyhal_psoc6_01_124_bga.c cyhal_psoc6_01_124_bga_sip.c cyhal_psoc6_01_43_smt.c cyhal_psoc6_01_68_qfn_ble.c cyhal_psoc6_01_80_wlcsp.c cyhal_psoc6_02_100_wlcsp.c cyhal_psoc6_02_124_bga.c cyhal_psoc6_02_128_tqfp.c cyhal_psoc6_02_68_qfn.c cyhal_psoc6_03_100_tqfp.c cyhal_psoc6_03_49_wlcsp.c cyhal_psoc6_03_68_qfn.c cyhal_psoc6_04_64_tqfp.c cyhal_psoc6_04_68_qfn.c cyhal_psoc6_04_80_m_csp.c cyhal_psoc6_04_80_tqfp.c cyhal_tviibe1m_100_lqfp.c cyhal_tviibe1m_144_lqfp.c cyhal_tviibe1m_176_lqfp.c cyhal_tviibe1m_64_lqfp.c cyhal_tviibe1m_80_lqfp.c cyhal_tviibe2m_100_lqfp.c cyhal_tviibe2m_144_lqfp.c cyhal_tviibe2m_176_lqfp.c cyhal_tviibe2m_64_lqfp.c cyhal_tviibe2m_80_lqfp.c cyhal_tviibe4m_100_lqfp.c cyhal_tviibe4m_144_lqfp.c cyhal_tviibe4m_176_lqfp.c cyhal_tviibe4m_64_lqfp.c cyhal_tviibe4m_80_lqfp.c
    ../mtb_shared/mtb-hal-cat1/release-v2.7.4/COMPONENT_CAT1A/source/triggers/: cyhal_triggers_psoc6_01.c cyhal_triggers_psoc6_02.c cyhal_triggers_psoc6_03.c cyhal_triggers_psoc6_04.c cyhal_triggers_tviibe1m.c cyhal_triggers_tviibe2m.c cyhal_triggers_tviibe4m.c
    ../mtb_shared/mtb-hal-cat1/release-v2.7.4/source/: cyhal_adc_mic.c cyhal_adc_sar.c cyhal_analog_common.c cyhal_audio_common.c cyhal_clock.c cyhal_comp.c cyhal_comp_ctb.c cyhal_comp_lp.c cyhal_crc.c cyhal_crypto_common.c cyhal_dac.c cyhal_dma.c cyhal_dma_dmac.c cyhal_dma_dw.c cyhal_ezi2c.c cyhal_gpio.c cyhal_hwmgr.c cyhal_i2c.c cyhal_i2s.c cyhal_interconnect.c cyhal_ipc.c cyhal_irq_impl.c cyhal_keyscan.c cyhal_lptimer.c cyhal_nvm.c cyhal_opamp.c cyhal_pdmpcm.c cyhal_pwm.c cyhal_qspi.c cyhal_quaddec.c cyhal_rtc.c cyhal_scb_common.c cyhal_sdhc.c cyhal_spi.c cyhal_syspm.c cyhal_system.c cyhal_tcpwm_common.c cyhal_tdm.c cyhal_timer.c cyhal_trng.c cyhal_uart.c cyhal_udb_sdio.c cyhal_usb_dev.c cyhal_utils.c cyhal_utils_impl.c cyhal_wdt.c cyhal_hwmgr_impl_part.h
    ../mtb_shared/mtb-hal-cat1/release-v2.7.4/COMPONENT_CAT1A/include/pin_packages/: cyhal_psoc6_01_104_m_csp_ble.h cyhal_psoc6_01_104_m_csp_ble_usb.h cyhal_psoc6_01_116_bga_ble.h cyhal_psoc6_01_116_bga_usb.h cyhal_psoc6_01_124_bga.h cyhal_psoc6_01_124_bga_sip.h cyhal_psoc6_01_43_smt.h cyhal_psoc6_01_68_qfn_ble.h cyhal_psoc6_01_80_wlcsp.h cyhal_psoc6_02_100_wlcsp.h cyhal_psoc6_02_124_bga.h cyhal_psoc6_02_128_tqfp.h cyhal_psoc6_02_68_qfn.h cyhal_psoc6_03_100_tqfp.h cyhal_psoc6_03_49_wlcsp.h cyhal_psoc6_03_68_qfn.h cyhal_psoc6_04_64_tqfp.h cyhal_psoc6_04_68_qfn.h cyhal_psoc6_04_80_m_csp.h cyhal_psoc6_04_80_tqfp.h cyhal_tviibe1m_100_lqfp.h cyhal_tviibe1m_144_lqfp.h cyhal_tviibe1m_176_lqfp.h cyhal_tviibe1m_64_lqfp.h cyhal_tviibe1m_80_lqfp.h cyhal_tviibe2m_100_lqfp.h cyhal_tviibe2m_144_lqfp.h cyhal_tviibe2m_176_lqfp.h cyhal_tviibe2m_64_lqfp.h cyhal_tviibe2m_80_lqfp.h cyhal_tviibe4m_100_lqfp.h cyhal_tviibe4m_144_lqfp.h cyhal_tviibe4m_176_lqfp.h cyhal_tviibe4m_64_lqfp.h cyhal_tviibe4m_80_lqfp.h
    ../mtb_shared/mtb-hal-cat1/release-v2.7.4/COMPONENT_CAT1A/include/triggers/: cyhal_triggers_psoc6_01.h cyhal_triggers_psoc6_02.h cyhal_triggers_psoc6_03.h cyhal_triggers_psoc6_04.h cyhal_triggers_tviibe1m.h cyhal_triggers_tviibe2m.h cyhal_triggers_tviibe4m.h
    ../mtb_shared/mtb-hal-cat1/release-v2.7.4/include/: cyhal.h cyhal_adc.h cyhal_clock.h cyhal_comp.h cyhal_crc.h cyhal_dac.h cyhal_dma.h cyhal_ezi2c.h cyhal_flash.h cyhal_general_types.h cyhal_gpio.h cyhal_hwmgr.h cyhal_i2c.h cyhal_i2s.h cyhal_interconnect.h cyhal_ipc.h cyhal_keyscan.h cyhal_lptimer.h cyhal_nvm.h cyhal_opamp.h cyhal_pdmpcm.h cyhal_pwm.h cyhal_qspi.h cyhal_quaddec.h cyhal_rtc.h cyhal_sdhc.h cyhal_sdio.h cyhal_spi.h cyhal_syspm.h cyhal_system.h cyhal_tdm.h cyhal_timer.h cyhal_trng.h cyhal_uart.h cyhal_usb_dev.h cyhal_wdt.h
    ../mtb_shared/mtb-hal-cat1/release-v2.7.4/include_pvt/: cyhal_adc_impl.h cyhal_analog_common.h cyhal_audio_common.h cyhal_clock_impl.h cyhal_comp_ctb.h cyhal_comp_lp.h cyhal_crc_impl.h cyhal_crypto_common.h cyhal_dma_dmac.h cyhal_dma_dw.h cyhal_dma_impl.h cyhal_drivers.h cyhal_gpio_impl.h cyhal_hw_resources.h cyhal_hw_types.h cyhal_hwmgr_impl.h cyhal_i2s_impl.h cyhal_interconnect_impl.h cyhal_ipc_impl.h cyhal_irq_impl.h cyhal_pdmpcm_impl.h cyhal_peri_common.h cyhal_pin_package.h cyhal_pwm_impl.h cyhal_quaddec_impl.h cyhal_scb_common.h cyhal_syspm_impl.h cyhal_system_impl.h cyhal_tcpwm_common.h cyhal_tdm_impl.h cyhal_timer_impl.h cyhal_triggers.h cyhal_trng_impl.h cyhal_utils.h cyhal_utils_impl.h cyhal_wdt_impl.h cyhal_wdt_impl_common.h
  group mtb-pdl-cat1
    ../mtb_shared/mtb-pdl-cat1/release-v3.17.0/devices/COMPONENT_CAT1A/source/: cy_device.c
    ../mtb_shared/mtb-pdl-cat1/release-v3.17.0/drivers/source/TOOLCHAIN_ARM/: cy_syslib_ext.s
    ../mtb_shared/mtb-pdl-cat1/release-v3.17.0/drivers/source/: cy_adcmic.c cy_axidmac.c cy_ble_clk.c cy_canfd.c cy_cordic.c cy_crypto.c cy_crypto_core_aes_v1.c cy_crypto_core_aes_v2.c cy_crypto_core_cmac_v1.c cy_crypto_core_cmac_v2.c cy_crypto_core_crc_v1.c cy_crypto_core_crc_v2.c cy_crypto_core_des_v1.c cy_crypto_core_des_v2.c cy_crypto_core_ecc_domain_params.c cy_crypto_core_ecc_ec25519.c cy_crypto_core_ecc_ecdsa.c cy_crypto_core_ecc_eddsa.c cy_crypto_core_ecc_key_gen.c cy_crypto_core_ecc_nist_p.c cy_crypto_core_hkdf_v2.c cy_crypto_core_hmac_v1.c cy_crypto_core_hmac_v2.c cy_crypto_core_hw.c cy_crypto_core_hw_v1.c cy_crypto_core_mem_v1.c cy_crypto_core_mem_v2.c cy_crypto_core_prng_v1.c cy_crypto_core_prng_v2.c cy_crypto_core_rsa.c cy_crypto_core_sha_v1.c cy_crypto_core_sha_v2.c cy_crypto_core_trng.c cy_crypto_core_vu.c cy_crypto_server.c cy_cryptolite_aes.c cy_cryptolite_aes_ccm.c cy_cryptolite_cmac.c cy_cryptolite_ecc_ec25519.c cy_cryptolite_ecc_eddsa.c cy_cryptolite_ecc_key_gen.c cy_cryptolite_ecdsa.c cy_cryptolite_hkdf.c cy_cryptolite_hmac.c cy_cryptolite_nist_p.c cy_cryptolite_rsa.c cy_cryptolite_sha256.c cy_cryptolite_trng.c cy_cryptolite_utils.c cy_cryptolite_vu.c cy_csd.c cy_ctb.c cy_ctdac.c cy_dma.c cy_dmac.c cy_efuse.c cy_efuse_v3.c cy_ephy.c cy_ethif.c cy_evtgen.c cy_flash.c cy_flash_srom.c cy_flash_v2.c cy_gpio.c cy_hppass.c cy_hppass_ac.c cy_hppass_csg.c cy_hppass_sar.c cy_i2s.c cy_ipc_bt.c cy_ipc_drv.c cy_ipc_pipe.c cy_ipc_sema.c cy_keyscan.c cy_lin.c cy_lpcomp.c cy_lvd.c cy_lvd_ht.c cy_mcwdt.c cy_mcwdt_b.c cy_mixer.c cy_mpc.c cy_ms_ctl.c cy_pdm_pcm.c cy_pdm_pcm_v2.c cy_ppc.c cy_pra.c cy_pra_cfg.c cy_profile.c cy_prot.c cy_rtc.c cy_sar.c cy_sar2.c cy_scb_common.c cy_scb_ezi2c.c cy_scb_i2c.c cy_scb_spi.c cy_scb_uart.c cy_sd_host.c cy_seglcd.c cy_smartio.c cy_smif.c cy_smif_hb_flash.c cy_smif_memslot.c cy_smif_sfdp.c cy_sysanalog.c cy_sysclk.c cy_sysclk_v2.c cy_sysfault.c cy_sysint.c cy_sysint_v2.c cy_syslib.c cy_syspm.c cy_syspm_btss.c cy_syspm_pdcm.c cy_syspm_ppu.c cy_syspm_v2.c cy_syspm_v3.c cy_syspm_v4.c cy_systick.c cy_systick_v2.c cy_tcpwm_counter.c cy_tcpwm_motif.c cy_tcpwm_pwm.c cy_tcpwm_quaddec.c cy_tcpwm_shiftreg.c cy_tdm.c cy_trigmux.c cy_usbfs_dev_drv.c cy_usbfs_dev_drv_io.c cy_usbfs_dev_drv_io_dma.c cy_wdt.c cy_wdt_b.c ppu_v1.c
    ../mtb_shared/mtb-pdl-cat1/release-v3.17.0/drivers/third_party/ethernet/src/: edd.c edd_rx.c edd_tx.c
    ../mtb_shared/mtb-pdl-cat1/release-v3.17.0/devices/COMPONENT_CAT1A/include/: cy8c4588azi_h675.h cy8c4588azi_h676.h cy8c4588azi_h685.h cy8c4588azi_h686.h cy8c4588azq_h685.h cy8c4588azq_h686.h cy8c6016bzi_f04.h cy8c6036bzi_f04.h cy8c6116bzi_f54.h cy8c6117bzi_f34.h cy8c6117fdi_f02.h cy8c6117wi_f34.h cy8c6136bzi_f14.h cy8c6136bzi_f34.h cy8c6136fdi_f42.h cy8c6136fti_f42.h cy8c6137bzi_f14.h cy8c6137bzi_f34.h cy8c6137bzi_f54.h cy8c6137fdi_f02.h cy8c6137wi_f54.h cy8c6144azi_s4f12.h cy8c6144azi_s4f62.h cy8c6144azi_s4f82.h cy8c6144azi_s4f83.h cy8c6144azi_s4f92.h cy8c6144azi_s4f93.h cy8c6144azq_s4f92.h cy8c6144azq_s4f93.h cy8c6144fmi_s4f03.h cy8c6144fmi_s4f53.h cy8c6144fmi_s4f73.h cy8c6144fmi_s4f93.h cy8c6144fmq_s4f93.h cy8c6144lqi_s4f12.h cy8c6144lqi_s4f62.h cy8c6144lqi_s4f82.h cy8c6144lqi_s4f92.h cy8c6144lqq_s4f92.h cy8c6145azi_s3f02.h cy8c6145azi_s3f12.h cy8c6145azi_s3f42.h cy8c6145azi_s3f62.h cy8c6145azi_s3f72.h cy8c6145fni_s3f11.h cy8c6145fni_s3f41.h cy8c6145fni_s3f71.h cy8c6145lqi_s3f02.h cy8c6145lqi_s3f12.h cy8c6145lqi_s3f42.h cy8c6145lqi_s3f62.h cy8c6145lqi_s3f72.h cy8c6146bti_f54.h cy8c6147bti_f54.h cy8c6148azi_s2f44.h cy8c6148bzi_s2f44.h cy8c6148fni_s2f43.h cy8c6148lqi_s2f02.h cy8c6148lqi_s2f42.h cy8c614aazi_s2f04.h cy8c614aazi_s2f14.h cy8c614aazi_s2f44.h cy8c614abzi_s2f04.h cy8c614abzi_s2f44.h cy8c614afni_s2f03.h cy8c614afni_s2f43.h cy8c614alqi_s2f02.h cy8c614alqi_s2f42.h cy8c6244azi_s4d12.h cy8c6244azi_s4d62.h cy8c6244azi_s4d82.h cy8c6244azi_s4d83.h cy8c6244azi_s4d92.h cy8c6244azi_s4d93.h cy8c6244azq_s4d92.h cy8c6244azq_s4d93.h cy8c6244fmi_s4d03.h cy8c6244fmi_s4d53.h cy8c6244fmi_s4d73.h cy8c6244fmi_s4d93.h cy8c6244fmq_s4d93.h cy8c6244lqi_s4d12.h cy8c6244lqi_s4d62.h cy8c6244lqi_s4d82.h cy8c6244lqi_s4d92.h cy8c6244lqq_s4d92.h cy8c6245azi_s3d02.h cy8c6245azi_s3d12.h cy8c6245azi_s3d42.h cy8c6245azi_s3d62.h cy8c6245azi_s3d72.h cy8c6245azq_s3d72.h cy8c6245fni_s3d11.h cy8c6245fni_s3d41.h cy8c6245fni_s3d71.h cy8c6245fnq_s3d41.h cy8c6245fnq_s3d71.h cy8c6245lqi_s3d02.h cy8c6245lqi_s3d12.h cy8c6245lqi_s3d42.h cy8c6245lqi_s3d62.h cy8c6245lqi_s3d72.h cy8c6245lqq_s3d72.h cy8c6246bti_d54.h cy8c6246bzi_d04.h cy8c6247bfi_d54.h cy8c6247bti_d54.h cy8c6247bzi_aud54.h cy8c6247bzi_d34.h cy8c6247bzi_d44.h cy8c6247bzi_d54.h cy8c6247fdi_d02.h cy8c6247fdi_d32.h cy8c6247fdi_d52.h cy8c6247fti_d52.h cy8c6247wi_d54.h cy8c6248azi_d14.h cy8c6248azi_d44.h cy8c6248azi_s2d14.h cy8c6248azi_s2d44.h cy8c6248bzi_d44.h cy8c6248bzi_s2d44.h cy8c6248fni_d43.h cy8c6248fni_s2d43.h cy8c6248lqi_s2d02.h cy8c6248lqi_s2d42.h cy8c624aazi_d14.h cy8c624aazi_d44.h cy8c624aazi_s2d14.h cy8c624aazi_s2d44.h cy8c624abzi_d04.h cy8c624abzi_d14.h cy8c624abzi_d44.h cy8c624abzi_s2d04.h cy8c624abzi_s2d14.h cy8c624abzi_s2d44.h cy8c624abzi_s2d44a0.h cy8c624afni_d43.h cy8c624afni_s2d43.h cy8c624alqi_d42.h cy8c624alqi_s2d02.h cy8c624alqi_s2d42.h cy8c6316bzi_blf03.h cy8c6316bzi_blf04.h cy8c6316bzi_blf53.h cy8c6316bzi_blf54.h cy8c6336bzi_bld13.h cy8c6336bzi_bld14.h cy8c6336bzi_blf03.h cy8c6336bzi_blf04.h cy8c6336bzi_bud13.h cy8c6336lqi_blf02.h cy8c6336lqi_blf42.h cy8c6337bzi_blf13.h cy8c6347bzi_bld33.h cy8c6347bzi_bld34.h cy8c6347bzi_bld43.h cy8c6347bzi_bld44.h cy8c6347bzi_bld53.h cy8c6347bzi_bld54.h cy8c6347bzi_bud33.h cy8c6347bzi_bud43.h cy8c6347bzi_bud53.h cy8c6347fmi_bld13.h cy8c6347fmi_bld33.h cy8c6347fmi_bld43.h cy8c6347fmi_bld53.h cy8c6347fmi_bud13.h cy8c6347fmi_bud33.h cy8c6347fmi_bud43.h cy8c6347fmi_bud53.h cy8c6347lqi_bld52.h cy8c637bzi_bld74.h cy8c637bzi_md76.h cy8c637fmi_bld73.h cy8c68237bz_ble.h cy8c68237fm_ble.h cy_device.h cy_device_common.h cy_device_headers.h cy_pdl.h cyb06445lqi_s3d42.h cyb06447bzi_bld53.h cyb06447bzi_bld54.h cyb06447bzi_d54.h cyb0644abzi_s2d44.h cyble_416045_02_device.h cys0644abzi_s2d44.h cys0644afni_s2d43.h cyt2b63bae.h cyt2b63bas.h cyt2b63cae.h cyt2b63cas.h cyt2b64bae.h cyt2b64bas.h cyt2b64cae.h cyt2b64cas.h cyt2b65bae.h cyt2b65bas.h cyt2b65cae.h cyt2b65cas.h cyt2b73bae.h cyt2b73bas.h cyt2b73cae.h cyt2b73cas.h cyt2b74bae.h cyt2b74bas.h cyt2b74cae.h cyt2b74cas.h cyt2b75bae.h cyt2b75bas.h cyt2b75cae.h cyt2b75cas.h cyt2b77bae.h cyt2b77bas.h cyt2b77cae.h cyt2b77cas.h cyt2b78bae.h cyt2b78bas.h cyt2b78cae.h cyt2b78cas.h cyt2b93bae.h cyt2b93bas.h cyt2b93cae.h cyt2b93cas.h cyt2b94bae.h cyt2b94bas.h cyt2b94cae.h cyt2b94cas.h cyt2b95bae.h cyt2b95bas.h cyt2b95cae.h cyt2b95cas.h cyt2b97bae.h cyt2b97bas.h cyt2b97cae.h cyt2b97cas.h cyt2b98bae.h cyt2b98bas.h cyt2b98cae.h cyt2b98cas.h cyt2bl3bae.h cyt2bl3bas.h cyt2bl3cae.h cyt2bl3cas.h cyt2bl4bae.h cyt2bl4bas.h cyt2bl4cae.h cyt2bl4cas.h cyt2bl5bae.h cyt2bl5bas.h cyt2bl5cae.h cyt2bl5cas.h cyt2bl7bae.h cyt2bl7bas.h cyt2bl7cae.h cyt2bl7cas.h cyt2bl8bae.h cyt2bl8bas.h cyt2bl8cae.h cyt2bl8cas.h cyusb2315_bf104axi.h cyusb2315a_bf104axi.h cyusb2316_bf104axi.h cyusb2317_bf104axi.h cyusb2318_bf104axi.h cyusb3081_fcaxi.h cyusb3082_fcaxi.h cyusb3083_fcaxi.h cyusb3084_fcaxi.h cyusb3282_fcaxi.h cyusb3284_fcaxi.h cyusb4011_fcaxi.h cyusb4012_fcaxi.h cyusb4013_fcaxi.h cyusb4014_fcaxi.h cyusb4021_fcaxi.h cyusb4022_fcaxi.h cyusb4024_bzxi.h fx3g2_config.h gpio_fx3g2_104_lga.h gpio_fx3g2_169_bga.h gpio_psoc6_01_104_m_csp_ble.h gpio_psoc6_01_104_m_csp_ble_usb.h gpio_psoc6_01_116_bga_ble.h gpio_psoc6_01_116_bga_usb.h gpio_psoc6_01_124_bga.h gpio_psoc6_01_124_bga_sip.h gpio_psoc6_01_68_qfn_ble.h gpio_psoc6_01_80_wlcsp.h gpio_psoc6_02_100_wlcsp.h gpio_psoc6_02_124_bga.h gpio_psoc6_02_128_tqfp.h gpio_psoc6_02_68_qfn.h gpio_psoc6_03_100_tqfp.h gpio_psoc6_03_49_wlcsp.h gpio_psoc6_03_68_qfn.h gpio_psoc6_04_64_tqfp.h gpio_psoc6_04_68_qfn.h gpio_psoc6_04_80_m_csp.h gpio_psoc6_04_80_tqfp.h gpio_tviibe1m_100_lqfp.h gpio_tviibe1m_144_lqfp.h gpio_tviibe1m_176_lqfp.h gpio_tviibe1m_64_lqfp.h gpio_tviibe1m_80_lqfp.h gpio_tviibe2m_100_lqfp.h gpio_tviibe2m_144_lqfp.h gpio_tviibe2m_176_lqfp.h gpio_tviibe2m_64_lqfp.h gpio_tviibe2m_80_lqfp.h gpio_tviibe4m_100_lqfp.h gpio_tviibe4m_144_lqfp.h gpio_tviibe4m_176_lqfp.h gpio_tviibe4m_64_lqfp.h gpio_tviibe4m_80_lqfp.h psoc6_01_config.h psoc6_02_config.h psoc6_03_config.h psoc6_04_config.h tviibe1m_config.h tviibe2m_config.h tviibe4m_config.h tviibe_remaps.h xmc5100_f100k576aa.h xmc5100_f64k576aa.h xmc5200_f100k1088aa.h xmc5200_f144k1088aa.h xmc5200_f64k1088aa.h xmc5300_f100k2112aa.h xmc5300_f144k2112aa.h
    ../mtb_shared/mtb-pdl-cat1/release-v3.17.0/devices/COMPONENT_CAT1A/include/ip/: cyip_backup.h cyip_backup_v2.h cyip_backup_v3_2.h cyip_ble.h cyip_canfd.h cyip_cpuss.h cyip_cpuss_v2.h cyip_crypto.h cyip_crypto_v2.h cyip_csd.h cyip_ctbm.h cyip_ctbm_v2.h cyip_ctdac.h cyip_ctdac_v2.h cyip_cxpi.h cyip_dmac_v2.h cyip_dw.h cyip_dw_v2.h cyip_efuse.h cyip_efuse_data_fx3g2.h cyip_efuse_data_psoc6_01.h cyip_efuse_data_psoc6_02.h cyip_efuse_data_psoc6_03.h cyip_efuse_data_psoc6_04.h cyip_efuse_data_tviibe1m.h cyip_efuse_data_tviibe2m.h cyip_efuse_data_tviibe4m.h cyip_efuse_v2.h cyip_epass.h cyip_evtgen.h cyip_fault.h cyip_fault_v2.h cyip_flashc.h cyip_flashc_v2.h cyip_flashc_v2_ect.h cyip_gpio.h cyip_gpio_v2.h cyip_gpio_v5.h cyip_headers.h cyip_hsiom.h cyip_hsiom_v2.h cyip_hsiom_v5.h cyip_i2s.h cyip_ipc.h cyip_ipc_v2.h cyip_lcd.h cyip_lcd_v2.h cyip_lin.h cyip_lpcomp.h cyip_lvdsss.h cyip_main_reg.h cyip_mxpdm.h cyip_mxs40usbhsdev.h cyip_pass.h cyip_pass_v2.h cyip_pdm.h cyip_peri.h cyip_peri_ms_v2.h cyip_peri_v2.h cyip_profile.h cyip_prot.h cyip_prot_v2.h cyip_sar.h cyip_sar_v2.h cyip_scb.h cyip_scb_v2.h cyip_sdhc.h cyip_sflash_fx3g2.h cyip_sflash_psoc6_01.h cyip_sflash_psoc6_02.h cyip_sflash_psoc6_03.h cyip_sflash_psoc6_04.h cyip_sflash_tviibe1m.h cyip_sflash_tviibe2m.h cyip_sflash_tviibe4m.h cyip_smartio.h cyip_smartio_v2.h cyip_smif.h cyip_srss.h cyip_srss_v2.h cyip_srss_v3_2.h cyip_tcpwm.h cyip_tcpwm_v2.h cyip_tdm_v2.h cyip_udb.h cyip_usb32dev.h cyip_usbfs.h
    ../mtb_shared/mtb-pdl-cat1/release-v3.17.0/drivers/include/: cy_adcmic.h cy_axidmac.h cy_ble_clk.h cy_canfd.h cy_cordic.h cy_crypto.h cy_crypto_common.h cy_crypto_config.h cy_crypto_core.h cy_crypto_core_aes.h cy_crypto_core_aes_v1.h cy_crypto_core_aes_v2.h cy_crypto_core_cmac.h cy_crypto_core_cmac_v1.h cy_crypto_core_cmac_v2.h cy_crypto_core_crc.h cy_crypto_core_crc_v1.h cy_crypto_core_crc_v2.h cy_crypto_core_des.h cy_crypto_core_des_v1.h cy_crypto_core_des_v2.h cy_crypto_core_ecc.h cy_crypto_core_ecc_nist_p.h cy_crypto_core_hkdf.h cy_crypto_core_hkdf_v2.h cy_crypto_core_hmac.h cy_crypto_core_hmac_v1.h cy_crypto_core_hmac_v2.h cy_crypto_core_hw.h cy_crypto_core_hw_v1.h cy_crypto_core_hw_v2.h cy_crypto_core_hw_vu.h cy_crypto_core_mem.h cy_crypto_core_mem_v1.h cy_crypto_core_mem_v2.h cy_crypto_core_prng.h cy_crypto_core_prng_v1.h cy_crypto_core_prng_v2.h cy_crypto_core_rsa.h cy_crypto_core_sha.h cy_crypto_core_sha_v1.h cy_crypto_core_sha_v2.h cy_crypto_core_trng.h cy_crypto_core_trng_config.h cy_crypto_core_vu.h cy_crypto_server.h cy_cryptolite.h cy_cryptolite_aes.h cy_cryptolite_aes_ccm.h cy_cryptolite_cmac.h cy_cryptolite_common.h cy_cryptolite_config.h cy_cryptolite_ecc_key_gen.h cy_cryptolite_ecdsa.h cy_cryptolite_hkdf.h cy_cryptolite_hmac.h cy_cryptolite_hw.h cy_cryptolite_nist_p.h cy_cryptolite_rsa.h cy_cryptolite_sha256.h cy_cryptolite_trng.h cy_cryptolite_trng_config.h cy_cryptolite_utils.h cy_cryptolite_vu.h cy_csd.h cy_ctb.h cy_ctdac.h cy_dma.h cy_dmac.h cy_efuse.h cy_ephy.h cy_ethif.h cy_evtgen.h cy_flash.h cy_flash_srom.h cy_gpio.h cy_hppass.h cy_hppass_ac.h cy_hppass_csg.h cy_hppass_sar.h cy_i2s.h cy_ipc_bt.h cy_ipc_drv.h cy_ipc_pipe.h cy_ipc_sema.h cy_keyscan.h cy_lin.h cy_lpcomp.h cy_lvd.h cy_lvd_ht.h cy_mcwdt.h cy_mixer.h cy_mpc.h cy_ms_ctl.h cy_pdm_pcm.h cy_pdm_pcm_v2.h cy_ppc.h cy_pra.h cy_pra_cfg.h cy_profile.h cy_prot.h cy_rtc.h cy_sar.h cy_sar2.h cy_scb_common.h cy_scb_ezi2c.h cy_scb_i2c.h cy_scb_spi.h cy_scb_uart.h cy_sd_host.h cy_seglcd.h cy_smartio.h cy_smif.h cy_smif_memslot.h cy_sysanalog.h cy_sysclk.h cy_sysfault.h cy_sysint.h cy_syslib.h cy_syspm.h cy_syspm_btss.h cy_syspm_pdcm.h cy_syspm_ppu.h cy_systick.h cy_tcpwm.h cy_tcpwm_counter.h cy_tcpwm_motif.h cy_tcpwm_pwm.h cy_tcpwm_quaddec.h cy_tcpwm_shiftreg.h cy_tdm.h cy_trigmux.h cy_usbfs_dev_drv.h cy_usbfs_dev_drv_pvt.h cy_usbfs_dev_drv_reg.h cy_wdt.h cyboot_flash_list.h ppu_v1.h
    ../mtb_shared/mtb-pdl-cat1/release-v3.17.0/drivers/third_party/ethernet/include/: cdn_errno.h cdn_stdint.h cedi.h cps_v2.h edd_int.h emac_regs.h emac_regs_macro.h log.h
  group retarget-io
    ../mtb_shared/retarget-io/release-v1.8.0/source/: cy_retarget_io.c
    ../mtb_shared/retarget-io/release-v1.8.0/include/: cy_retarget_io.h
