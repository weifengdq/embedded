# Keil uVision project a503_spi_quad_flash.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: GD32A503KC GigaDevice
  pack: GigaDevice.GD32A50x_DFP.1.6.0
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x040000) IROM2(0x08800000,0x010000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: a503_spi_quad_flash +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32A50X
  c include: ..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32A50x\Include;..\Firmware\GD32A50x_standard_peripheral\Include;.\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT5: ROM 0x8800000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group CMSIS
    ../Firmware/CMSIS/GD/GD32A50x/Source/: system_gd32a50x.c
  group Peripherals
    ../Firmware/GD32A50x_standard_peripheral/Source/: gd32a50x_adc.c gd32a50x_bkp.c gd32a50x_can.c gd32a50x_cmp.c gd32a50x_crc.c gd32a50x_dac.c gd32a50x_dbg.c gd32a50x_dma.c gd32a50x_exti.c gd32a50x_fmc.c gd32a50x_fwdgt.c gd32a50x_gpio.c gd32a50x_i2c.c gd32a50x_mfcom.c gd32a50x_misc.c gd32a50x_pmu.c gd32a50x_rcu.c gd32a50x_rtc.c gd32a50x_spi.c gd32a50x_syscfg.c gd32a50x_timer.c gd32a50x_trigsel.c gd32a50x_usart.c gd32a50x_wwdgt.c
  group Startup
    ../Firmware/CMSIS/GD/GD32A50x/Source/ARM/: startup_gd32a50x.s
  group Source
    ./Source/: gd32a50x_it.c main.c systick.c gd25qxx.c
software components: CMSIS:CORE 6.1.1
